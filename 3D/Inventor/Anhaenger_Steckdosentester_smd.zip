# Autodesk Inventor part: Board
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2023-03
Part Number: Board
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: Board
Author: AdminForWorker
## Design history (mm, degrees)
feature "Board"
body "Solid1"
