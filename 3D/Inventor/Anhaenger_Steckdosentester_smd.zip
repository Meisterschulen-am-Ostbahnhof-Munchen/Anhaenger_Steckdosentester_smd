# Autodesk Inventor part: SMB
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2023-03
Part Number: SMB
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: SMB
Author: AdminForWorker
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
